# Keil uVision project 2.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 2
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 2.c lcd.h infrared.h com.h
