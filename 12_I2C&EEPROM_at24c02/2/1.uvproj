# Keil uVision project 1.uvproj, settings and files
target UART (MCS-51)
  device: STC90C58AD STC-STC90
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Head_File
  group Star_File
    ./: STARTUP.A51
  group USER
    ./USER/: main.c lcd.c usart.c i2c.c eeprom.c
