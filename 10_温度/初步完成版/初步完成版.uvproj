# Keil uVision project 初步完成版.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC90C58RD+ STC-STC90
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: 初步完成版 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 温度.c
