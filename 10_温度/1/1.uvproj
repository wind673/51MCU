# Keil uVision project 1.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC89LE58RD+ STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 1.c
