# Keil uVision project 1.uvproj, settings and files
target UART (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: UART +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Head_File
  group Star_File
    ./: STARTUP.A51
  group USER
    ./USER/: main.c lcd.c uart.c delay.c
