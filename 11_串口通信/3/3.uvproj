# Keil uVision project 3.uvproj, settings and files
target UART (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Head_File
  group USER
    ./USER/: main.c delay.c lcd.c uart.c
    ./: STARTUP.A51
